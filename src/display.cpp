#include "display.h"
#include "config.h"
#include "driver/spi_master.h"
#include "esp_heap_caps.h"

// Init sequence for the FNK0104N ST77922 panel. The register values come
// from Freenove's reference driver for this board; they are panel-specific
// timing/gamma settings and are needed as-is to light the glass.
namespace {

struct InitCmd {
  uint8_t cmd;
  uint8_t len;
  uint16_t delayMs;
  uint8_t data[16];
};

const InitCmd kInit[] = {
    {0xF1, 1, 0, {0x00}},
    {0x60, 3, 0, {0x00, 0x00, 0x00}},
    {0x65, 1, 0, {0x80}},
    {0x79, 1, 0, {0x06}},
    {0x7B, 3, 0, {0x00, 0x08, 0x08}},
    {0x80, 11, 0, {0x55, 0x62, 0x2F, 0x17, 0xF0, 0x52, 0x70, 0xD2, 0x52, 0x62, 0xEA}},
    {0x81, 4, 0, {0x26, 0x52, 0x72, 0x27}},
    {0x84, 2, 0, {0x92, 0x25}},
    {0x87, 6, 0, {0x10, 0x10, 0x58, 0x00, 0x02, 0x3A}},
    {0x88, 15, 0, {0x00, 0x00, 0x2C, 0x10, 0x04, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x06}},
    {0x89, 3, 0, {0x00, 0x00, 0x00}},
    {0x8A, 11, 0, {0x13, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x10, 0x10, 0x00, 0x3E, 0x19}},
    {0x8B, 9, 0, {0x15, 0xB1, 0xB1, 0x44, 0x96, 0x2C, 0x10, 0x97, 0x8E}},
    {0x8C, 13, 0, {0x1D, 0xB1, 0xB1, 0x44, 0x96, 0x2C, 0x10, 0x50, 0x0F, 0x01, 0xC5, 0x12, 0x09}},
    {0x8D, 1, 0, {0x0C}},
    {0x8E, 6, 0, {0x33, 0x01, 0x0C, 0x13, 0x01, 0x01}},
    {0xB3, 2, 0, {0x00, 0x30}},
    {0xF1, 1, 0, {0x00}},
    {0x71, 1, 0, {0xD0}},
    {0x66, 2, 0, {0x02, 0x3F}},
    {0xBE, 3, 0, {0x26, 0x00, 0x9D}},
    {0x70, 12, 0, {0x01, 0xA0, 0x11, 0x40, 0xE0, 0x00, 0x11, 0x69, 0x11, 0x00, 0x00, 0x1A}},
    {0x90, 9, 0, {0x04, 0x04, 0x55, 0x74, 0x00, 0x40, 0x43, 0x27, 0x27}},
    {0x91, 9, 0, {0x04, 0x04, 0x55, 0x75, 0x00, 0x40, 0x42, 0x27, 0x27}},
    {0x92, 10, 0, {0x04, 0x44, 0x55, 0xC0, 0x06, 0x00, 0x07, 0x05, 0x90, 0x27}},
    {0x93, 10, 0, {0x04, 0x43, 0x11, 0x00, 0x00, 0x00, 0x00, 0x05, 0x90, 0x27}},
    {0x94, 6, 0, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00}},
    {0x95, 5, 0, {0x96, 0x16, 0x00, 0x00, 0xFF}},
    {0x96, 12, 0, {0x44, 0x53, 0x03, 0x12, 0x23, 0x24, 0x06, 0x05, 0x94, 0x27, 0x00, 0x44}},
    {0x97, 12, 0, {0x44, 0x53, 0x47, 0x56, 0x20, 0x20, 0x02, 0x01, 0x94, 0x27, 0x00, 0x44}},
    {0xBA, 5, 0, {0x55, 0x94, 0x2D, 0x94, 0x27}},
    {0x9A, 7, 0, {0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00}},
    {0x9B, 7, 0, {0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00}},
    {0x9C, 13, 0, {0x5C, 0x12, 0x00, 0x00, 0x10, 0x12, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00}},
    {0x9D, 8, 0, {0x8A, 0x51, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01}},
    {0x9E, 7, 0, {0x51, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01}},
    {0xB4, 12, 0, {0x1D, 0x1C, 0x1E, 0x0B, 0x14, 0x02, 0x13, 0x09, 0x1E, 0x00, 0x1E, 0x10}},
    {0xB5, 12, 0, {0x1D, 0x1C, 0x1E, 0x0A, 0x15, 0x03, 0x11, 0x08, 0x1E, 0x01, 0x1E, 0x12}},
    {0xB6, 7, 0, {0x77, 0x77, 0x00, 0x0A, 0xFF, 0x0A, 0xFF}},
    {0x86, 14, 0, {0xCD, 0x04, 0xB1, 0x02, 0x58, 0x12, 0x58, 0x0C, 0x13, 0x01, 0xA5, 0x00, 0xA5, 0xA5}},
    {0xB7, 16, 0, {0x07, 0x0A, 0x0E, 0x06, 0x05, 0x03, 0x2B, 0x03, 0x03, 0x42, 0x07, 0x10, 0x10, 0x2E, 0x3F, 0x0D}},
    {0xB8, 16, 0, {0x07, 0x0A, 0x0D, 0x05, 0x05, 0x02, 0x2B, 0x02, 0x03, 0x42, 0x06, 0x10, 0x0F, 0x2E, 0x3F, 0x0D}},
    {0xB9, 2, 0, {0x23, 0x23}},
    {0xBF, 6, 0, {0x10, 0x14, 0x14, 0x0B, 0x0B, 0x0B}},
    {0xF2, 1, 0, {0x00}},
    {0x73, 5, 0, {0x04, 0xDA, 0x12, 0x54, 0x47}},
    {0x77, 5, 0, {0x6B, 0x5B, 0xFD, 0xC3, 0xC5}},
    {0x7A, 2, 0, {0x15, 0x27}},
    {0x7B, 2, 0, {0x04, 0x57}},
    {0x7E, 2, 0, {0x01, 0x0E}},
    {0xBF, 1, 0, {0x36}},
    {0xE3, 2, 0, {0x40, 0x40}},
    {0xF0, 1, 0, {0x00}},
    {0xD0, 1, 0, {0x00}},
    {0x2A, 4, 0, {0x00, 0x00, 0x01, 0x3F}},
    {0x2B, 4, 0, {0x00, 0x00, 0x01, 0xDF}},
    {0x21, 0, 0, {}},
    {0x11, 0, 120, {}},
    {0x29, 0, 0, {}},
    {0x2C, 0, 0, {}},
    {0x3A, 1, 0, {0x01}},
    {0x36, 1, 0, {0x00}},
    {0x35, 1, 20, {0x01}},
};

constexpr uint8_t QSPI_CMD_1W = 0x02;  // single-line register write
constexpr uint8_t QSPI_CMD_4W = 0x32;  // quad pixel write
constexpr uint8_t RAMWR = 0x2C;
constexpr uint8_t RAMWRC = 0x3C;

// Strip = N physical (portrait) rows = N logical (landscape) columns.
constexpr int STRIP_ROWS = 40;
constexpr int STRIP_PIXELS = LCD_NATIVE_W * STRIP_ROWS;
constexpr int NUM_STRIPS = LCD_NATIVE_H / STRIP_ROWS;  // 12

spi_device_handle_t s_dev = nullptr;
uint16_t* s_strip[2] = {nullptr, nullptr};
spi_transaction_ext_t s_trans[2];
bool s_inflight[2] = {false, false};

void writeReg(uint8_t cmd, const uint8_t* data, uint8_t len) {
  spi_transaction_ext_t t;
  memset(&t, 0, sizeof(t));
  t.base.flags = SPI_TRANS_VARIABLE_CMD | SPI_TRANS_VARIABLE_ADDR;
  t.base.cmd = QSPI_CMD_1W;
  t.base.addr = ((uint32_t)cmd) << 8;
  t.command_bits = 8;
  t.address_bits = 24;
  t.base.tx_buffer = len ? data : nullptr;
  t.base.length = 8 * len;
  spi_device_polling_transmit(s_dev, (spi_transaction_t*)&t);
}

void setWindow(uint16_t x0, uint16_t y0, uint16_t x1, uint16_t y1) {
  uint8_t xd[4] = {(uint8_t)(x0 >> 8), (uint8_t)x0, (uint8_t)(x1 >> 8), (uint8_t)x1};
  uint8_t yd[4] = {(uint8_t)(y0 >> 8), (uint8_t)y0, (uint8_t)(y1 >> 8), (uint8_t)y1};
  writeReg(0x2A, xd, 4);
  writeReg(0x2B, yd, 4);
}

void waitSlot(int i) {
  if (!s_inflight[i]) return;
  spi_transaction_t* done;
  spi_device_get_trans_result(s_dev, &done, portMAX_DELAY);
  s_inflight[i] = false;
}

void queueStrip(int i, bool first) {
  spi_transaction_ext_t& t = s_trans[i];
  memset(&t, 0, sizeof(t));
  t.base.flags = SPI_TRANS_MODE_QIO | SPI_TRANS_VARIABLE_CMD | SPI_TRANS_VARIABLE_ADDR;
  t.base.cmd = QSPI_CMD_4W;
  t.base.addr = ((uint32_t)(first ? RAMWR : RAMWRC)) << 8;
  t.command_bits = 8;
  t.address_bits = 24;
  t.base.tx_buffer = s_strip[i];
  t.base.length = STRIP_PIXELS * 16;
  spi_device_queue_trans(s_dev, (spi_transaction_t*)&t, portMAX_DELAY);
  s_inflight[i] = true;
}

}  // namespace

namespace display {

bool begin() {
  // Backlight off while we init to avoid showing garbage
  ledcAttach(PIN_LCD_BL, 20000, 8);
  ledcWrite(PIN_LCD_BL, 0);

  spi_bus_config_t bus = {};
  bus.data0_io_num = PIN_QSPI_D0;
  bus.data1_io_num = PIN_QSPI_D1;
  bus.sclk_io_num = PIN_QSPI_SCLK;
  bus.data2_io_num = PIN_QSPI_D2;
  bus.data3_io_num = PIN_QSPI_D3;
  bus.max_transfer_sz = STRIP_PIXELS * 2 + 8;
  // GPIO 9-14 are the SPI2 IOMUX pins on the S3, so 80 MHz is reachable
  bus.flags = SPICOMMON_BUSFLAG_MASTER | SPICOMMON_BUSFLAG_QUAD | SPICOMMON_BUSFLAG_IOMUX_PINS;
  if (spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO) != ESP_OK) return false;

  spi_device_interface_config_t dev = {};
  dev.mode = 0;
  dev.clock_speed_hz = LCD_QSPI_HZ;
  dev.spics_io_num = PIN_LCD_CS;
  dev.flags = SPI_DEVICE_HALFDUPLEX;
  dev.queue_size = 4;
  if (spi_bus_add_device(SPI2_HOST, &dev, &s_dev) != ESP_OK) return false;

  for (int i = 0; i < 2; i++) {
    s_strip[i] = (uint16_t*)heap_caps_malloc(STRIP_PIXELS * 2, MALLOC_CAP_DMA | MALLOC_CAP_INTERNAL);
    if (!s_strip[i]) return false;
  }

  for (const auto& c : kInit) {
    writeReg(c.cmd, c.data, c.len);
    if (c.delayMs) delay(c.delayMs);
  }
  return true;
}

void setBacklight(uint8_t level) { ledcWrite(PIN_LCD_BL, level); }

void pushFrame(const uint16_t* frame) {
  // Landscape logical (lx, ly) -> portrait physical (px = 319 - ly, py = lx).
  // Physical row py is logical column lx, so a strip of STRIP_ROWS physical
  // rows is a band of STRIP_ROWS logical columns. We walk logical rows
  // sequentially (cache friendly PSRAM reads) and scatter into the strip.
  setWindow(0, 0, LCD_NATIVE_W - 1, LCD_NATIVE_H - 1);
  int slot = 0;
  for (int s = 0; s < NUM_STRIPS; s++) {
    waitSlot(slot);
    uint16_t* dst = s_strip[slot];
    const int x0 = s * STRIP_ROWS;
    for (int ly = 0; ly < SCREEN_H; ly++) {
      const uint16_t* src = frame + ly * SCREEN_W + x0;
      uint16_t* d = dst + (LCD_NATIVE_W - 1 - ly);
      for (int k = 0; k < STRIP_ROWS; k++) {
        *d = src[k];
        d += LCD_NATIVE_W;
      }
    }
    queueStrip(slot, s == 0);
    slot ^= 1;
  }
  waitSlot(0);
  waitSlot(1);
}

}  // namespace display
